Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-08-31T15:03:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 31 15:03:49 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{D4980174-3145-465E-8BA0-A292B1EC18E4}\ifc * Database version: 5507 * Database creation date: Fri Aug 31 15:03:48 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 31 15:03:48 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 31 15:03:48 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 8510 Washbasin faucet, 8510:8510 Washbasin faucet:343318
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - NominalDepth: 229 mm; NominalHeight: 146.5 mm; NominalWidth: 70 mm; Projection: 200 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 8510; ConvergoRefNr: 0087-1809-0144-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_07; Uniclass2015Description: Bath manual water supply sets; Uniclass2015Reference: Pr_40_20_87_07; Version: 1; VersionDate: 30/07/2018
Type - Green Building Properties(Type) - EAN Number: 6414150045097; EN Standard: EN 817; LVI Number: 6118610; Noise Class: I (ISO 3822); NRF Number: 4201232; Protection Class: IP 55; RSK Number: 8553319; Sintef Certificate: Sintef Nr. 0966; STF Certificate: STF VTT-09183-06; VVS Number: 702450004
Type - Identity Data(Type) - Class: Single lever; Group: Washbasin faucets; Manufacturer: Oras; Market: INT;FIN;NOR;POL;RUS;EST;LTU;LVA;UKR; Model: 8510 Washbasin faucet; Name_en: 8510 Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 8510; Product Datasheet: https://www.oras.com/datasheet/8510/en; Product Family: IL BAGNO ALESSI One by Oras; Product URL: https://www.oras.com/en/products/oras/product/8510; Type Name: 8510 Washbasin faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Aerator: HONEYCOMB®; Connection: Covered eccentric unions; Connection Size: G1/2; Flow Rate At 300kPa: 0.00706293 m3/s; Installation and Maintenance: https://www.oras.com/fileadmin/resources/110214_PDM_945450_C_(945450-01-16).pdf; Installation Type: Wall-mounted; Max. Hot Water Supply: 80 kg/K/s3; Pressure Loss With Flow 01ls: 75000 Pa; Spare Parts: https://www.oras.com/en/products/oras/spareparts/SP8510/; Spout Type: Fixed spout
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Bathroom; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 8510; Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 8510; Name: 8510 Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 70x230x150 mm; SustainabilityPerformance: n/a; WarrantyDescription: https://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 8510; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 8510 Washbasin faucet
Constraints - DefaultElevation: 800 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0614043 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 20 mm; OutletAngle: 0 deg; Volume: 0.00236096 m3
Identity Data - Mark: 15
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 8510: 8510 Washbasin faucet; Family and Type: 8510: 8510 Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 8510: 8510 Washbasin faucet; Type Id: 8510: 8510 Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
